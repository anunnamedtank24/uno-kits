#ifndef GRAPHICS_TEXT_H
#define GRAPHICS_TEXT_H

#include <stdint.h>
#include <stddef.h>
#include <math.h>

namespace graphics {
    namespace detail {
        // true only for bool itself (no pointer -> bool, no int -> bool)
        template <class T> struct IsBool { static constexpr bool value = false; };
        template <> struct IsBool<bool> { static constexpr bool value = true; };

        template <bool condition, class T> struct EnableIf {};
        template <class T> struct EnableIf<true, T> { using type = T; };
    }

    // text on top of Shapes, fonts generated by lib/font/source/convert.py
    //
    // Screen: a class providing (see lib/graphics/shapes.h, lib/ST7789/basic/datasheet.h)
    //   drawPoint, drawHLineSize, drawVLineSize, fillRectSize (lib/graphics/shapes.h)
    //   BusType::readFlash8(const uint8_t *) / BusType::readFlash16(const uint16_t *)
    //   BusType::FlashString: type of strings kept in flash (Arduino F("...")),
    //                         any unused struct if the board has none
    //
    // Font: a struct providing (every struct in namespace font, see lib/font/font.h)
    //   gridHeight, first, last, defaultIndex
    //   getWidths(), getOffsets(), getShapes()
    //
    // only the pixels of a char are drawn (its shapes), the background is left as it is
    // chars outside first ~ last are drawn as the font's default char
    //
    // Screen also needs width() for setAutoLineBreak(true)
    template <class Screen>
    class Text : public Screen {
    public:
        using Screen::Screen;

        // ---------- font ----------

        template <class Font>
        inline void setFont();
        inline uint8_t fontHeight() const;

        // ---------- format ----------

        // digits after the point for float / double (default 2)
        inline void setDecimals(uint8_t decimals);

        // drawn between the elements of an array (default "", kept as a pointer)
        inline void setSeparator(const char *separator);

        // ---------- layout ----------

        // extra px between lines, line height = fontHeight() + spacing (default 0)
        inline void setLineSpacing(uint8_t spacing);

        // true: '\n' starts a new line, and a char that does not fit the screen width
        // moves to a new line; a new line starts at the x given to drawTexts()
        // a char that still does not fit on a new line is drawn anyway (cut), checked once
        // false (default): '\n' is drawn as the default char, nothing wraps
        inline void setAutoLineBreak(bool autoLineBreak);

        // ---------- text ----------

        // any number of values, drawn one after another from (x, y) = top-left
        //   char                      a char
        //   bool                      true / false
        //   integers (incl. int8_t)   decimal number
        //   float / double            decimal number, setDecimals() digits, nan / inf / ovf
        //   const char *, char[]      string
        //   F("...")                  string kept in flash
        //   anything with c_str()     string (e.g. Arduino String)
        //   T[N]                      every element, setSeparator() between them
        // returns x after the last char (on the last line)
        template <class... Values>
        inline int16_t drawTexts(int16_t x, int16_t y, uint16_t color, const Values &... values);

    private:
        using Bus = typename Screen::BusType;
        using FlashString = typename Bus::FlashString;

        const uint8_t *_widths = nullptr;
        const uint16_t *_offsets = nullptr;
        const uint8_t *_shapes = nullptr;
        uint8_t _gridHeight = 0;
        uint8_t _first = 0;
        uint8_t _last = 0;
        uint8_t _defaultIndex = 0;
        uint8_t _decimals = 2;
        const char *_separator = "";
        uint8_t _lineSpacing = 0;
        bool _autoLineBreak = false;

        // set by drawTexts(): x of every line start, y of the current line
        int16_t _lineStartX = 0;
        int16_t _lineY = 0;

        inline int16_t newLine();

        inline int16_t drawValues(int16_t x, uint16_t color);
        template <class First, class... Rest>
        inline int16_t drawValues(int16_t x, uint16_t color, const First &first, const Rest &... rest);

        inline int16_t drawValue(int16_t x, uint16_t color, char value);
        inline int16_t drawValue(int16_t x, uint16_t color, const char *value);
        inline int16_t drawValue(int16_t x, uint16_t color, const FlashString *value);

        // bool only, "true" / "false"
        template <class Bool>
        inline auto drawValue(int16_t x, uint16_t color, const Bool &value)
            -> typename detail::EnableIf<detail::IsBool<Bool>::value, int16_t>::type;
        inline int16_t drawValue(int16_t x, uint16_t color, signed char value);
        inline int16_t drawValue(int16_t x, uint16_t color, unsigned char value);
        inline int16_t drawValue(int16_t x, uint16_t color, short value);
        inline int16_t drawValue(int16_t x, uint16_t color, unsigned short value);
        inline int16_t drawValue(int16_t x, uint16_t color, int value);
        inline int16_t drawValue(int16_t x, uint16_t color, unsigned int value);
        inline int16_t drawValue(int16_t x, uint16_t color, long value);
        inline int16_t drawValue(int16_t x, uint16_t color, unsigned long value);
        inline int16_t drawValue(int16_t x, uint16_t color, long long value);
        inline int16_t drawValue(int16_t x, uint16_t color, unsigned long long value);
        inline int16_t drawValue(int16_t x, uint16_t color, float value);
        inline int16_t drawValue(int16_t x, uint16_t color, double value);
        inline int16_t drawValue(int16_t x, uint16_t color, long double value);

        // anything with c_str()
        template <class String>
        inline auto drawValue(int16_t x, uint16_t color, const String &value)
            -> decltype((void)value.c_str(), int16_t());

        // arrays (char arrays go to const char *)
        template <class Value, size_t N>
        inline int16_t drawValue(int16_t x, uint16_t color, const Value (&values)[N]);

        template <class Signed, class Unsigned>
        inline int16_t drawSigned(int16_t x, uint16_t color, Signed value);
        template <class Unsigned>
        inline int16_t drawUnsigned(int16_t x, uint16_t color, Unsigned value);
        inline int16_t drawFloat(int16_t x, uint16_t color, double value);

        // one char: reads its shapes (points, hLines, vLines, rects) and draws each
        inline int16_t drawChar(int16_t x, uint16_t color, char c);
    };

    // ================= definitions =================

    // ---------- font ----------

    template <class Screen>
    template <class Font>
    inline void Text<Screen>::setFont() {
        _widths = Font::getWidths();
        _offsets = Font::getOffsets();
        _shapes = Font::getShapes();
        _gridHeight = Font::gridHeight;
        _first = Font::first;
        _last = Font::last;
        _defaultIndex = Font::defaultIndex;
    }

    template <class Screen>
    inline uint8_t Text<Screen>::fontHeight() const {
        return _gridHeight;
    }

    // ---------- format ----------

    template <class Screen>
    inline void Text<Screen>::setDecimals(uint8_t decimals) {
        _decimals = decimals;
    }

    template <class Screen>
    inline void Text<Screen>::setSeparator(const char *separator) {
        _separator = separator ? separator : "";
    }

    // ---------- layout ----------

    template <class Screen>
    inline void Text<Screen>::setLineSpacing(uint8_t spacing) {
        _lineSpacing = spacing;
    }

    template <class Screen>
    inline void Text<Screen>::setAutoLineBreak(bool autoLineBreak) {
        _autoLineBreak = autoLineBreak;
    }

    // next line, returns its start x
    template <class Screen>
    inline int16_t Text<Screen>::newLine() {
        _lineY += _gridHeight + _lineSpacing;
        return _lineStartX;
    }

    // ---------- text ----------

    template <class Screen>
    template <class... Values>
    inline int16_t Text<Screen>::drawTexts(int16_t x, int16_t y, uint16_t color, const Values &... values) {
        _lineStartX = x;
        _lineY = y;
        return drawValues(x, color, values...);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValues(int16_t x, uint16_t color) {
        (void)color;
        return x;
    }

    template <class Screen>
    template <class First, class... Rest>
    inline int16_t Text<Screen>::drawValues(int16_t x, uint16_t color, const First &first, const Rest &... rest) {
        x = drawValue(x, color, first);
        return drawValues(x, color, rest...);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, char value) {
        return drawChar(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, const char *value) {
        if (!value) {
            return x;
        }
        while (*value) {
            x = drawChar(x, color, *value);
            value++;
        }
        return x;
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, const FlashString *value) {
        if (!value) {
            return x;
        }
        const uint8_t *address = reinterpret_cast<const uint8_t *>(value);
        for (char c = (char)Bus::readFlash8(address); c != '\0'; c = (char)Bus::readFlash8(address)) {
            x = drawChar(x, color, c);
            address++;
        }
        return x;
    }

    template <class Screen>
    template <class Bool>
    inline auto Text<Screen>::drawValue(int16_t x, uint16_t color, const Bool &value)
        -> typename detail::EnableIf<detail::IsBool<Bool>::value, int16_t>::type {
        return drawValue(x, color, value ? "true" : "false");
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, signed char value) {
        return drawSigned<long, unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, unsigned char value) {
        return drawUnsigned<unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, short value) {
        return drawSigned<long, unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, unsigned short value) {
        return drawUnsigned<unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, int value) {
        return drawSigned<long, unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, unsigned int value) {
        return drawUnsigned<unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, long value) {
        return drawSigned<long, unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, unsigned long value) {
        return drawUnsigned<unsigned long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, long long value) {
        return drawSigned<long long, unsigned long long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, unsigned long long value) {
        return drawUnsigned<unsigned long long>(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, float value) {
        return drawFloat(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, double value) {
        return drawFloat(x, color, value);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, long double value) {
        return drawFloat(x, color, (double)value);
    }

    template <class Screen>
    template <class String>
    inline auto Text<Screen>::drawValue(int16_t x, uint16_t color, const String &value)
        -> decltype((void)value.c_str(), int16_t()) {
        return drawValue(x, color, (const char *)value.c_str());
    }

    template <class Screen>
    template <class Value, size_t N>
    inline int16_t Text<Screen>::drawValue(int16_t x, uint16_t color, const Value (&values)[N]) {
        for (size_t i = 0; i < N; i++) {
            if (i > 0) {
                x = drawValue(x, color, _separator);
            }
            x = drawValue(x, color, values[i]);
        }
        return x;
    }

    template <class Screen>
    template <class Signed, class Unsigned>
    inline int16_t Text<Screen>::drawSigned(int16_t x, uint16_t color, Signed value) {
        if (value < 0) {
            x = drawChar(x, color, '-');
            // works for the most negative value too
            return drawUnsigned<Unsigned>(x, color, (Unsigned)0 - (Unsigned)value);
        }
        return drawUnsigned<Unsigned>(x, color, (Unsigned)value);
    }

    template <class Screen>
    template <class Unsigned>
    inline int16_t Text<Screen>::drawUnsigned(int16_t x, uint16_t color, Unsigned value) {
        // 20 digits fit 2^64, + '\0'
        char digits[21];
        uint8_t i = sizeof(digits) - 1;
        digits[i] = '\0';
        do {
            i--;
            digits[i] = (char)('0' + value % 10);
            value /= 10;
        } while (value > 0);
        return drawValue(x, color, (const char *)&digits[i]);
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawFloat(int16_t x, uint16_t color, double value) {
        if (isnan(value)) {
            return drawValue(x, color, "nan");
        }
        if (isinf(value)) {
            return drawValue(x, color, value < 0 ? "-inf" : "inf");
        }
        if (value < 0) {
            x = drawChar(x, color, '-');
            value = -value;
        }

        // round at the last digit
        double rounding = 0.5;
        for (uint8_t i = 0; i < _decimals; i++) {
            rounding /= 10.0;
        }
        value += rounding;

        // integer part must fit unsigned long (same limit as Arduino print)
        if (value > 4294967040.0) {
            return drawValue(x, color, "ovf");
        }

        unsigned long integer = (unsigned long)value;
        x = drawUnsigned<unsigned long>(x, color, integer);
        if (_decimals == 0) {
            return x;
        }

        x = drawChar(x, color, '.');
        double rest = value - (double)integer;
        for (uint8_t i = 0; i < _decimals; i++) {
            rest *= 10.0;
            uint8_t digit = (uint8_t)rest;
            x = drawChar(x, color, (char)('0' + digit));
            rest -= digit;
        }
        return x;
    }

    template <class Screen>
    inline int16_t Text<Screen>::drawChar(int16_t x, uint16_t color, char c) {
        if (!_shapes) {
            return x;
        }

        if (_autoLineBreak && c == '\n') {
            return newLine();
        }

        uint8_t code = (uint8_t)c;
        uint8_t index = (code < _first || code > _last) ? _defaultIndex : (uint8_t)(code - _first);
        uint8_t width = Bus::readFlash8(_widths + index);
        const uint8_t *shape = _shapes + Bus::readFlash16(_offsets + index);

        // does not fit: new line once; at a line start it is drawn anyway
        if (_autoLineBreak && x != _lineStartX && (int32_t)x + width > (int32_t)this->width()) {
            x = newLine();
        }
        int16_t y = _lineY;

        // counts, then points (x, y), hLines (x, y, w), vLines (x, y, h), rects (x, y, w, h)
        uint8_t pointCount = Bus::readFlash8(shape);
        uint8_t hLineCount = Bus::readFlash8(shape + 1);
        uint8_t vLineCount = Bus::readFlash8(shape + 2);
        uint8_t rectCount = Bus::readFlash8(shape + 3);
        shape += 4;

        for (uint8_t i = 0; i < pointCount; i++) {
            uint8_t pointX = Bus::readFlash8(shape);
            uint8_t pointY = Bus::readFlash8(shape + 1);
            this->drawPoint(x + pointX, y + pointY, color);
            shape += 2;
        }
        for (uint8_t i = 0; i < hLineCount; i++) {
            uint8_t lineX = Bus::readFlash8(shape);
            uint8_t lineY = Bus::readFlash8(shape + 1);
            uint8_t lineW = Bus::readFlash8(shape + 2);
            this->drawHLineSize(x + lineX, y + lineY, lineW, color);
            shape += 3;
        }
        for (uint8_t i = 0; i < vLineCount; i++) {
            uint8_t lineX = Bus::readFlash8(shape);
            uint8_t lineY = Bus::readFlash8(shape + 1);
            uint8_t lineH = Bus::readFlash8(shape + 2);
            this->drawVLineSize(x + lineX, y + lineY, lineH, color);
            shape += 3;
        }
        for (uint8_t i = 0; i < rectCount; i++) {
            uint8_t rectX = Bus::readFlash8(shape);
            uint8_t rectY = Bus::readFlash8(shape + 1);
            uint8_t rectW = Bus::readFlash8(shape + 2);
            uint8_t rectH = Bus::readFlash8(shape + 3);
            this->fillRectSize(x + rectX, y + rectY, rectW, rectH, color);
            shape += 4;
        }
        return x + width;
    }
}

#endif
